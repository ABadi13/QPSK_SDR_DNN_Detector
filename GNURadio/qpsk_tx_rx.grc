options:
  parameters:
    generate_options: qt_gui
    id: QPSK_Tx_Rx
    output_language: python
    title: QPSK Tx Rx
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '20'
  states: {}
- name: SNR__FRS
  id: variable
  parameters:
    value: '''{}__4''.format(SNR)'
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '1000'
    value: '70'
  states: {state: disabled}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Freq correction
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '20'
    value: '10'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: SNR
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: op_freq
  id: variable
  parameters:
    value: 1033e6
  states: {}
- name: osps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: path
  id: variable
  parameters:
    value: '"F:\\Ahmed Badi\\Documents\\Programming & Simmulation\\GNU Radio\\Datasets\\TEST\\"+SNR__FRS'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.0628'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, +0.707-0.707j, +0.707+0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: ' firdes.root_raised_cosine (nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: '0.0628'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '64'
    min: '0'
    num_samps: int(1.25e7)
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: path + 'sd'
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: path + 'od'
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: path + 'TxSignal'
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: path + 'RxSignal'
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0_0
  id: blocks_file_sink
  parameters:
    file: path + 'RxSignalUnsynched'
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: path + 'BitsPilots.bin'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: SDR
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_cma_equalizer_cc_0
  id: digital_cma_equalizer_cc
  parameters:
    modulus: '1'
    mu: eq_gain
    num_taps: '1'
    sps: osps
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
    verbose: 'True'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    use_snr: 'True'
    w: phase_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: osps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/sps/1.2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/32
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    corr0: freq_correction
    freq0: op_freq
    gain0: '0'
    if_gain0: '20'
    sample_rate: samp_rate_2
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'received@0: 0,0,1,1'
    label1: Received Signal
    name: '"Constellation Diagram"'
    size: '1024'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'received@1: 0,0,1,1'
    label1: Transmitted Signal
    name: '"Tx"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'received@2: 0,0,1,1'
    label1: Received Signal
    name: '"Rx"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-40'
    ymin: '-120'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate_2/samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate_2/samp_rate)
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,1,1,1
    label0: Constellation
    label1: Tx Signal
    label2: Rx Signal
    label3: Tab 3
    label4: Tab 4
    num_tabs: '5'
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: op_freq
    gain0: gain
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate_2
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TxSignal
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: SynchedSignal
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: OriginalBits
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: RxSignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TxSignal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RxSignal
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: SynchedSignal
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_throttle_1, '0', virtual_sink_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_1, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_file_sink_0_0, '0']
- [digital_cma_equalizer_cc_0, '0', digital_costas_loop_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_file_sink_0_0_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle_1, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_constellation_modulator_0_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0_0_1_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0_0_1_0_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0_0, '0', digital_cma_equalizer_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0_0, '0', rational_resampler_xxx_1, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0_0, '0', digital_pfb_clock_sync_xxx_0_0_0, '0']
- [virtual_source_0_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_0_0_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
